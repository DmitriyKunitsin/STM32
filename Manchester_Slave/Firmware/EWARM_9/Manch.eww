<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Manch.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\Manchester_Master\Firmware\EWARM_9\Manch.ewp</path>
    </project>
    <batchBuild />
</workspace>

# IAR project Backup of RUS_Regul.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433CC ST STM32L433CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FREERTOS; USE_PLATFORM_OKR_354_10; PLATFORM_MODIFICATION_DEFAULT; ASSERT_USE_CALL_STACK; USE_MOTOR_CM36_3650
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\Source\Src; ..\Source\Library\Platforms; ..\Source\Library\Platforms\Components; ..\Source\Library\Platforms\Common; ..\Source\Library\Platforms\Common\STM32L4xx; ..\Source\Library\Tools\Memory; ..\Source\Library\Tools\SKLP; ..\Source\Library\Tools\SKLP\Interfaces; ..\Source\Library\Tools\Utils; ..\Source\Library\Drivers\CMSIS\Include; ..\Source\Library\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\Source\Library\Drivers\STM32L4xx_HAL_Driver\Inc; ..\Source\Library\Middlewares\FreeRTOS\Source\include; ..\Source\Library\Middlewares\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Source\Src; ..\Source\Library\Platforms\Common
  OBJCOPY.OOCOutputFile: RUS_Regul.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/ST/stm32l433xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration SMALL_MOTOR_NO_STOPS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FREERTOS; USE_PLATFORM_OKR_354_10; PLATFORM_MODIFICATION_DEFAULT; ASSERT_USE_CALL_STACK; USE_SMALL_MOTOR
configuration CM36_3650_MOTOR_NO_STOPS (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\SVN_Hardware\Projects\RUS\RUS_Regul\Firmware\EWARM_9\RUS_Regul.icf
configuration SMALL_MOTOR_WITH_STOPS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FREERTOS; USE_PLATFORM_OKR_354_10; PLATFORM_MODIFICATION_DEFAULT; ASSERT_USE_CALL_STACK; USE_SMALL_MOTOR; DUMPER_WITH_STOPS
  ILINK.IlinkIcfFile: C:\SVN_Hardware\Projects\RUS\RUS_Regul\Firmware\EWARM\RUS_Regul.icf
configuration CM36_3650_MOTOR_WITH_STOPS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FREERTOS; USE_PLATFORM_OKR_354_10; PLATFORM_MODIFICATION_DEFAULT; ASSERT_USE_CALL_STACK; USE_MOTOR_CM36_3650; DUMPER_WITH_STOPS
  group (top)
    ../Source/Src/: BuildInfo.c
  group Application
    ../Source/Src/: main.c RUS_Regul_ADC.c RUS_Regul_Main.c RUS_Regul_Periphery.c RUS_Regul_PeripheryPD.c SKLP_Interface_RUS_Regul.c SKLP_MS_TransportLocal_354_10.c
  group Application/Tools/SKLP
    ../Source/Library/Tools/SKLP/: SKLP_MS_Transport.c SKLP_Service.c SKLP_ServiceDefault.c SKLP_Time.c
  group Application/Tools/Utils
    ../Source/Library/Tools/Utils/: ByteQueue.c eeprom_emul.c MathUtils.c NVM.c RebootUtils.c Utils.c
    ../Source/Src/: flash_interface.c
  group Drivers/CMSIS
    ../Source/Library/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l433xx.s
  group Drivers/Components
    ../Source/Library/Platforms/Components/: Driver_ADS1231.c DRIVER_CM36-3650.c DRIVER_Motor.c DRIVER_Small_Motor.c
  group Drivers/PlatformCommon
    ../Source/Library/Platforms/Common/: Common_dac.c common_gpio.c common_rcc.c Common_tim.c common_uart.c Stm32xxxx_hal_uart_ext.c
  group Drivers/PlatformCommon/STM32L4xx
    ../Source/Library/Platforms/Common/STM32L4xx/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Used
    ../Source/Library/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_adc.c
  group Middlewares/FreeRTOS
    ../Source/Library/Middlewares/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CortexM4-F
    ../Source/Library/Middlewares/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FreeRTOS/Heap
    ../Source/Library/Middlewares/FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
